# IAR project ADC_DMA.ewp, settings and files
configuration ADC_DMA (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM32F429I_DISCO
  ICCARM.CCIncludePath2: ..\; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\CMSIS\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Utilities\STM32F429I-Discovery; ..\usb_cdc_device; ..\Library\STM32F4xx_StdPeriph_Driver\inc; ..\User\inc; ..\FatFS10\inc; ..\CMSIS\inc; ..\User\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_DMA.hex
  ILINK.IlinkOutputFile: ADC_DMA.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
  group Function
    ../User/src/: co2.c EKG.c IBP.c NIBP.c spo2.c Temperature.c
  group Language
    ../User/src/: Chinese.c Deutsch.c English.c Espan.c Franc.c Italia.c
    ../User/inc/: Japanese.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f3xx_hal_smbus.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../CMSIS/src/: system_stm32f4xx.c
  group usb_cdc_device
    ../usb_cdc_device/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group User
    ../User/src/: crc16.c fonts.c graphics.c lcd.c main.c printer.c printer_D2.c sdram.c smbus.c spi_flash.c spi_sd.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_it.c sys_Alarm.c sys_AnalogOutput.c sys_autorun.c sys_draw.c sys_init.c sys_Internet.c sys_key.c sys_mem.c sys_menu.c sys_misc.c sys_mq.c sys_rtc.c sys_spi.c sys_timer.c sys_touch.c sys_uart.c tm_stm32f4_usb_vcp.c tsc2046.c
    ../Library/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_i2c.c
